# Keil uVision project RotationDriver.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103V8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWMDriver
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: FlashMemory.cpp Port.cpp SysTick.cpp Timer.cpp main.cpp RotationDriverThread.cpp PWMControl.cpp DriverControl.cpp RotationDriver.cpp
  group Header
    ./: main.h FlashMemory.h Port.h SysTick.h Timer.h RotationDriverThread.h CANProtocol.h PWMControl.h DriverControl.h RotationDriver.h
  group SSD1315
    ./: defines.h font6x8.h font8x16.h LCDIF.h ssd1306xled.h LCDIF.cpp ssd1306xled.cpp
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
